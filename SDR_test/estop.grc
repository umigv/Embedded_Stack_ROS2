options:
  parameters:
    generate_options: qt_gui
    id: estop
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: dc_blocker_xx_1
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '[0.7] * 750'
    type: fcf
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 50e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 50e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '500'
    ymin: '100'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    marker2: '1'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '30'
    corr0: '46'
    freq0: 433.96e6
    gain0: '20'
    gain_mode0: 'True'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [dc_blocker_xx_1, '0', low_pass_filter_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_2, '0']
- [rtlsdr_source_0, '0', dc_blocker_xx_1, '0']

metadata:
  file_format: 1
